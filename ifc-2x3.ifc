Properties of the parts of a building model (IFC2X3)

# File
Description: Hülsentemperaturfühler, NTC 50K, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: G9031456, Hülsentemperaturfühler, NTC 50K
In: Raum
Description: Hülsentemperaturfühler, NTC50 K, 4 m, Fühlerleitung Silikon; Classification: EC004240 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: G9031456; ModelLabel: HF-5/4K3; GlobalTradeItemNumber: 4050528074362; ProductURL: https://alre.de/produkt_G9031456
Pset_Specification - NominalLength: 4 m; NominalWidth: 0.006 m; NominalDepth: 0.006 m; NetWeight: 0.24
Pset_ALRE_ETIM_Properties - Kabellänge: 4; Art der Spannungsversorgung: ohne; Geeignet für Rohrmontage: yes; Umgebungstemperatur: -50; Explosionsgeschützt: no; Schutzart (IP): IP65; Mit Befestigungsmaterial: no; Einsatzgebiet: Tauchrohr/-kanal; Geeignet für Flüssigkeiten: yes; Geeignet für Gase: yes; Aktive Temperaturmessung: no; Passive Temperaturmessung: yes; Max. Umgebungsfeuchtigkeit (nicht kondensierend): 95; Durchmesser Sensorelement: 8; Einstecklänge: 28; Gehäusehöhe: 6; Gehäusebreite: 6; Gehäusetiefe: 4000; Geeignet für Kanalbefestigung: yes; Festes Kabel am Sensor: yes; Material Element: rostfreier Stahl; Länge des Sensors: 28; Geeignet für Luft: yes; ETIM-Klasse: EC004240; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-G9031456.pdf
